# Keil uVision project 初始库.uvprojx, settings and files
target Target 1 (5050106::V5.05 update 1 (build 106)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 初始库 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD,USE_STM3210E_EVAL
  c include: .\CMSIS;.\FWLIB\inc;.\FWLIB\src;.\User;.\User\DMA;.\User\SPI;.\User\LCD;.\User\delay;.\User\sys;.\User\usart;.\User\SDIO_SD\STM3210E_EVAL;.\User\SDIO_SD;.\User\FatFs;.\User\FatFs\option
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ./CMSIS/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ./FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ./User/: main.c system_stm32f10x.c
  group LCD
    ./User/SPI/: spi.c
    ./User/LCD/: lcd_init.c lcd.c
    ./User/DMA/: dma.c
    ./User/sys/: sys.c
    ./User/delay/: delay.c
  group SDIO_SD
    ./User/SDIO_SD/: stm32_eval_sdio_sd.c
  group FatFs
    ./User/FatFs/: diskio.c ff.c
    ./User/FatFs/option/: cc936.c
